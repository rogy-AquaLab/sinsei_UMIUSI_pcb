# Repository rogy-AquaLab/sinsei_UMIUSI_pcb

File README.md:

# 新生UMIUSIの回路
- 円形基板を積層し、スペースを有効利用
- 表面実装部品の多用による小型化
- 補助マイコン廃止によるプログラムの簡略化

## KiCad design back_connector_esc/back_connector_esc.kicad_pcb

Board: 2 copper layers, 22.0 x 33.0 mm, 6 parts (0 on the bottom side), 3 nets, no tracks yet.

Parts:
H1, H2, H3: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J2, J3, J4: Conn_02x08_Odd_Even; PinSocket_2x08_P2.54mm_Vertical

Connections:
PHASE1: H1.1, J2.1, J2.2, J2.3, J2.4, J2.5, J2.6, J2.7, J2.8, J2.9, J2.10, J2.11, J2.12, J2.13, J2.14, J2.15, J2.16
PHASE2: H2.1, J3.1, J3.2, J3.3, J3.4, J3.5, J3.6, J3.7, J3.8, J3.9, J3.10, J3.11, J3.12, J3.13, J3.14, J3.15, J3.16
PHASE3: H3.1, J4.1, J4.2, J4.3, J4.4, J4.5, J4.6, J4.7, J4.8, J4.9, J4.10, J4.11, J4.12, J4.13, J4.14, J4.15, J4.16

## KiCad design can_connector/can_connector.kicad_pcb

Parts:
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x06_Pin; PinHeader_1x06_P2.54mm_Vertical
J2, J3, J4, J5: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J6: Conn_01x06_Pin; JST_XH_S6B-XH-A-1_1x06_P2.50mm_Horizontal
M1, M2, M3: Fan; PinHeader_1x02_P2.54mm_Vertical

Connections:
+5V: J1.1, J6.1, M1.1 (+), M2.1 (+), M3.1 (+)
CANH: J1.2, J2.1, J3.1, J4.1, J5.1, J6.2
CANL: J1.3, J2.2, J3.2, J4.2, J5.2, J6.3
GND: J1.4, J6.4, M1.2 (-), M2.2 (-), M3.2 (-)
SCL: J1.6, J6.6
SDA: J1.5, J6.5

Board: 2 copper layers, 102.0 x 35.6 mm, 21 parts (16 on the bottom side), 6 nets.

## KiCad design back_connector_base/back_connector_base.kicad_pcb

Parts:
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x12_Pin; PinHeader_1x12_P2.54mm_Horizontal
J2: Conn_01x16_Pin; PinHeader_1x16_P2.54mm_Horizontal
J3, J4, J5, J6: Conn_01x03_Socket; PinSocket_1x03_P2.54mm_Vertical
J7, J8, J9, J10: Conn_01x04_Socket; PinSocket_1x04_P2.54mm_Vertical
J11, J12: Conn_01x04_Pin; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J13: Conn_01x06_Pin; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
JP1: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
R1: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Connections:
+5V: J11.1, J12.1, J13.1
A_B: J2.15, J7.2
A_G: J2.13, J7.4
A_GND: J2.16, J7.1
A_R: J2.14, J7.3
B_B: J2.11, J8.2
B_G: J2.9, J8.4
B_GND: J2.12, J8.1
B_R: J2.10, J8.3
C_B: J2.7, J9.2
C_G: J2.5, J9.4
C_GND: J2.8, J9.1
C_R: J2.6, J9.3
D_B: J2.3, J10.2
D_G: J2.1, J10.4
D_GND: J2.4, J10.1
D_R: J2.2, J10.3
GND: J11.4, J12.4, J13.4
unnamed: J1.1, J3.3
unnamed: J1.2, J3.2
unnamed: J1.3, J3.1
unnamed: J1.4, J4.3
unnamed: J1.5, J4.2
unnamed: J1.6, J4.1
unnamed: J1.7, J5.3
unnamed: J1.8, J5.2
unnamed: J1.9, J5.1
unnamed: J1.10, J6.3
unnamed: J1.11, J6.2
unnamed: J1.12, J6.1
unnamed: J11.2, J13.2, R1.2
unnamed: J11.3, J13.3, JP1.2 (B)
unnamed: J12.2, J13.5
unnamed: J12.3, J13.6
unnamed: JP1.1 (A), R1.1

Notes on the sheet:
CAN
I2C

Board: 2 copper layers, 101.8 x 76.0 mm, 18 parts (3 on the bottom side), 35 nets.

## KiCad design control_unit/control_unit.kicad_pcb

Parts:
C1, C2: 22p; C_0603_1608Metric; LCSC C1653
C3, C5: 100n; C_0603_1608Metric; LCSC C14663
C4: 0.01u; C_0603_1608Metric; LCSC C57112
Cbst1: 0.1u; C_0603_1608Metric; LCSC C14663
Cc1: 2.2n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C1604
Cc2: 12p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C38523
Cc3: 3.3n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C1613
Cin1, Cin2, Cin3, Cin4, Cin5, Cin6, Cin7, Cin8, Cin9, Cin10, Cin11, Cin12: 10u; C_1210_3225Metric; LCSC C126612
Cout1, Cout2: 100p; C_0603_1608Metric; LCSC C14858
Cout3, Cout4, Cout5, Cout6, Cout7: 47u; C_1210_3225Metric; LCSC C162512
Css1: 0.1u; C_0603_1608Metric; LCSC C14663
Cvcc1: 2.2u; C_0603_1608Metric; LCSC C23630
Cvin1: 0.1u; C_0603_1608Metric; LCSC C14663
D1: SS36; D_SMA; LCSC C7420367
D2: SS34; D_SMA; LCSC C8678
ESC1, ESC2, ESC3, ESC4: PinHeader_1x03_P2.54mm_Vertical
Fan1: Fan; PinHeader_1x02_P2.54mm_Vertical
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_3.2mm_M3
J1: Barrel_Jack_Switch; BarrelJack_Horizontal
J2: Conn_01x02_Socket; JST_VH_B2P-VH_1x02_P3.96mm_Vertical
J3: SERVO_PWM; JST_XA_B04B-XASK-1-A_1x04_P2.50mm_Vertical
J4: Conn_01x04_Pin; JST_XA_B04B-XASK-1-A_1x04_P2.50mm_Vertical
J5: Conn_01x02_Pin; JST_XA_B02B-XASK-1-A_1x02_P2.50mm_Vertical
J6: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
JP1, JP2: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP3: Jumper_2_Bridged; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
L1, L2: 10u; IND-SMD_L13.8-W12.6; LCSC C149518
LED1: Emerald; LED_0805_2012Metric; LCSC C2297
LED_BNO1: GREEN; LED_0805_2012Metric; LCSC C2296
LED_ESC_1, LED_ESC_2, LED_ESC_3, LED_ESC_4: RED; LED_0805_2012Metric; LCSC C84256
LED_PCB1: Conn_01x06_Pin; JST_XA_B06B-XASK-1-A_1x06_P2.50mm_Vertical
Q1, Q2: AO3400A; SOT-23; LCSC C20917
Q3, Q4, Q5: 2N7002; SOT-23; LCSC C8545
Q6, Q7: TO-252-2
R1, R7, R10, R17, R19, R24: 1.2k; R_0603_1608Metric; LCSC C22765
R2, R3, R4, R5, R14, R15: 100m; R_1206_3216Metric; LCSC C25334
R6, R8, R16, R18, R22, R23: 10k; R_0603_1608Metric; LCSC C25804
R9: 1.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22765
R11: 13k; R_0603_1608Metric; LCSC C22797
R12: 3k; R_0603_1608Metric; LCSC C4211
R20, R21: 5.1k; R_0603_1608Metric; LCSC C23186
RV1: 10k; TSR-3386
R_CAN1: 120; R_1206_3216Metric; LCSC C17909
R_reset1: 100k; R_0603_1608Metric; LCSC C25803
Rc1: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C23179
Rc2: 13k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22797
Rfb1: 18k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C25810
Rfb2: 3.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22978
Rilim1: 180; R_0603_1608Metric; LCSC C22828
Rpg1: 51k; R_0603_1608Metric; LCSC C23196
Rt1: 33k; R_0603_1608Metric; LCSC C4216
Ruv1: 75k; R_0603_1608Metric; LCSC C23242
Ruv2: 12k; R_0603_1608Metric; LCSC C22790
SERVO_TEST1: Motor_Servo; PinHeader_1x03_P2.54mm_Vertical
TP1, TP2: TestPoint; Pin_D1.0mm_L10.0mm
U1: VQFN-20_L4.5-W3.5-P0.50-BL-EP; Manufacturer Part LM5146RGYR; LCSC Part Name LM5146RGYR
U2: CL6808; SOT-89-5
U3: RaspberryPi4 hat
U4: MCP2515-xSO; SOIC-18W_7.5x11.6mm_P1.27mm; LCSC C12368
U5: ATA6561-GAQW-N; SOIC8_4P9X3P9MC_MCH
U6: ADS1015IDGS; TSSOP-10_3x3mm_P0.5mm; LCSC C193969
U7: BNO055 DIP
USER_LED1: YELLOW; LED_0805_2012Metric; LCSC C2296
X1: 16MHz; OSC-SMD_4P-L3.2-W2.5-BL; Manufacturer Part X322516MLB4SI; LCSC Part Name 16MHz ±10ppm 9pF

Connections:
+3.3V_1: C4.1, R22.1, U3.1 (3V3), U6.8 (VDD)
+3.3V_2: C5.2, JP1.2 (B), JP2.2 (B), R_reset1.2, U3.17 (3V3), U4.18 (VDD), U5.5 (VIO), U7.1 (VIN)
+5.1V: C3.2, Cout1.2, Cout2.2, Cout3.1, Cout4.1, Cout5.1, Cout6.1, Cout7.1, D2.1 (K), Fan1.1 (+), L2.2, LED_PCB1.1, R9.2, R11.1, R14.1, R16.1, Rc1.2, Rfb1.2, Rpg1.2, SERVO_TEST1.2 (+), TP2.1, U2.5 (VIN), U3.2 (5V), U3.4 (5V), U5.3 (VCC)
+7.5V: Cvcc1.1, U1.14 (VCC)
+24V: Cin1.1, Cin2.1, Cin3.1, Cin4.1, Cin5.1, Cin6.1, Cin7.1, Cin8.1, Cin9.1, Cin10.1, Cin11.1, Cin12.1, Cvin1.1, Q6.2 (D), R2.2, R3.2, R4.2, R5.2, Ruv1.1, U1.20 (VIN)
CANH: J5.1, J6.1, R_CAN1.1, U5.7 (CANH)
CANL: J5.2, J6.2, JP3.1 (A), U5.6 (CANL)
CS0: U3.24 (GPIO8(CE0)), U4.16 (~CS)
ESC1_RP4: ESC1.1, U3.40 (GPIO21(PCM_DOUT))
ESC2_RP4: ESC2.1, U3.35 (GPIO19(PCM_FS,_PWM1))
ESC3_RP4: ESC3.1, U3.36 (GPIO16)
ESC4_RP4: ESC4.1, U3.32 (GPIO12(PWM0))
GND: C1.1, C2.1, C3.1, C4.2, C5.1, Cin1.2, Cin2.2, Cin3.2, Cin4.2, Cin5.2, Cin6.2, Cin7.2, Cin8.2, Cin9.2, Cin10.2, Cin11.2, Cin12.2, Cout1.1, Cout2.1, Cout3.2, Cout4.2, Cout5.2, Cout6.2, Cout7.2, Css1.1, Cvcc1.2, Cvin1.2, ESC1.3, ESC2.3, ESC3.3, ESC4.3, Fan1.2 (-), J1.2, J1.3, J2.2, LED_BNO1.1 (K), LED_ESC_1.1 (K), LED_ESC_2.1 (K), LED_ESC_3.1 (K), LED_ESC_4.1 (K), LED_PCB1.6, Q1.2 (S), Q2.2 (S), Q3.3 (D), Q4.2 (S), Q5.2 (S), Q7.3 (S), R6.2, R8.2, R12.2, R18.1, R23.2, Rfb2.1, Rt1.1, Ruv2.2, SERVO_TEST1.3 (-), TP1.1, U1.6 (AGND), U1.8 (SYNCIN), U1.9 (NC), U1.12 (PGND), U1.15 (EP), U1.16 (NC), U1.21 (EP), U2.2 (GND), U3.6 (GND), U3.9 (GND), U3.14 (GND), U3.20 (GND), U3.25 (GND), U3.30 (GND), U3.34 (GND), U3.39 (GND), U4.9 (VSS), U5.2 (GND), U5.8 (STBY), U6.3 (GND), U7.2 (GND), U7.7 (GND), USER_LED1.1 (K), X1.2 (GND), X1.4 (GND)
HighBeam: Q5.1 (G), R18.2, U3.29 (GPIO5)
INT: U3.38 (GPIO20(PCM_DIN)), U4.12 (~INT)
IR: Q1.1 (G), R6.1, U3.22 (GPIO25)
LowBeam: Q2.1 (G), R8.1, U3.31 (GPIO6)
MISO: U3.21 (GPIO9(MISO)), U4.15 (SO)
MOSI: U3.19 (GPIO10(MOSI)), U4.14 (SI)
unnamed: Cc1.1, Rc1.1
unnamed: Cc3.1, Rc2.1
unnamed: D1.2 (A), J1.1, J2.1
unnamed: D1.1 (K), R2.1, R3.1, R4.1, R5.1
unnamed: D2.2 (A), L1.1, U2.1 (LX)
unnamed: ESC1.2, R1.1
unnamed: ESC2.2, R7.1
unnamed: ESC3.2, R10.1
unnamed: ESC4.2, R17.1
unnamed: J4.1, U6.4 (AIN0)
unnamed: J4.2, U6.5 (AIN1)
unnamed: J4.3, U6.6 (AIN2)
unnamed: J4.4, U6.7 (AIN3)
unnamed: JP1.1 (A), R21.2
unnamed: JP2.1 (A), R20.2
unnamed: JP3.2 (B), R_CAN1.2
unnamed: LED1.2 (A), R9.1
unnamed: LED1.1 (K), Q3.2 (S)
unnamed: LED_BNO1.2 (A), R24.2
unnamed: LED_ESC_1.2 (A), R1.2
unnamed: LED_ESC_2.2 (A), R7.2
unnamed: LED_ESC_3.2 (A), R10.2
unnamed: LED_ESC_4.2 (A), R17.2
unnamed: LED_PCB1.2, Q2.3 (D)
unnamed: LED_PCB1.3, Q1.3 (D)
unnamed: LED_PCB1.4, R15.2, U2.4 (ISNS)
unnamed: L1.2, LED_PCB1.5
unnamed: Q3.1 (G), Rpg1.1, U1.10 (PGOOD)
unnamed: Q4.3 (D), RV1.2, U2.3 (ADJ)
unnamed: Q4.1 (G), Q5.3 (D), R16.2
unnamed: Q6.1 (G), U1.18 (HO)
unnamed: Cbst1.2, L2.1, Q6.3 (S), Q7.2 (D), Rilim1.2, U1.19 (SW)
unnamed: Q7.1 (G), U1.13 (LO)
unnamed: R11.2, RV1.1
unnamed: R12.1, RV1.3
unnamed: R14.2, R15.1
unnamed: Cbst1.1, U1.17 (BST)
unnamed: Cc2.2, Cc3.2, U1.4 (COMP)
unnamed: Ruv1.2, Ruv2.1, U1.1 (EN/UVLO)
unnamed: Cc1.2, Cc2.1, Rc2.2, Rfb1.1, Rfb2.2, U1.5 (FB)
unnamed: Rilim1.1, U1.11 (ILIM)
unnamed: Rt1.2, U1.2 (RT)
unnamed: Css1.2, U1.3 (SS/TRK)
unnamed: C1.2, U4.8 (OSC1), X1.1 (OSC1)
unnamed: C2.2, U4.7 (OSC2), X1.3 (OSC2)
unnamed: U4.2 (RXCAN), U5.4 (RXD)
unnamed: U4.1 (TXCAN), U5.1 (TXD)
unnamed: R_reset1.1, U4.17 (~RESET)
unnamed: R23.1, U6.1 (ADDR)
unnamed: R22.2, U6.2 (ALERT/RDY)
unnamed: R24.1, U7.8 (VOUT)
unnamed: R19.2, USER_LED1.2 (A)
SCK: U3.23 (GPIO11(SCLK)), U4.13 (SCK)
SCL: R20.1, U3.5 (GPIO3(SCL)), U6.10 (SCL), U7.4 (SCL)
SDA: R21.1, U3.3 (GPIO2(SDA)), U6.9 (SDA), U7.3 (SDA)
SERVO1: J3.1, U3.7 (GPIO4)
SERVO2: J3.2, U3.12 (GPIO18(PCM_CLK,_PWM0))
SERVO3: J3.3, U3.11 (GPIO17)
SERVO4: J3.4, U3.33 (GPIO13(PWM1))
SERVO_test: SERVO_TEST1.1 (PWM), U3.37 (GPIO26)
USER_LED: R19.1, U3.18 (GPIO24)

Notes on the sheet:
I2C Device
RaspberryPi4
HighBeam GPIO5 LowBeam GPIO6 IR GPIO25
SERVO1 G4 SERVO2 G18 SERVO3 G17 SERVO4 G13
Rated Voltage = 60V
ESC1 G21 ESC2 G19 ESC3 G16 ESC4 G12
Rated Voltage = 50V
ESC_OLD
fsw = 40kHzくらい
LED
DCR=20m
DC DC converter
Iled = (5.1V - 2.8V) / 1.2k = 1.92mA
CAN
High Power LED
Rated Voltage = 100V
Vadj = 0.59 ~ 2.55V
Vin_on=8.7V

Board: 2 copper layers, 100.0 x 95.0 mm, 116 parts (4 on the bottom side), 80 nets.
